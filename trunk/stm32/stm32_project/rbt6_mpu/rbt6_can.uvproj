# Keil uVision project rbt6_can.uvproj, settings and files
target rbt6_can (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rbt6_can +hex
  c flags: Optim=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: .\src\Libraries\CMSIS\CM3\CoreSupport;.\src\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\src\uCOS-II\Ports;.\src\uCOS-II\Source;.\src\task;.\src;.\src\driver;.\src\Libraries\STM32F10x_StdPeriph_Driver\inc;.\src\protocol;.\src\protocol\protocolio;.\src\protocol\parse
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./src/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ./src/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./src/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c
  group lib
    ./src/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_can.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_i2c.c
  group config
    ./src/: config.h
  group main
    ./src/: bsp.c main.c stm32f10x_it.c debug.c
  group task
    ./src/task/: task_start.h task_app.h task_start.c task_uarttocan.c task_key.c
  group driver
    ./src/driver/: led.c key.c uart.c can.c i2c.c i2c.h mpu9150.c mpu9150.h
  group protocol
    ./src/protocol/: protocol.h commonres.h protocol.c
    ./src/protocol/protocolio/: protocolio.c
    ./src/protocol/parse/: check.c identify.c
  group uCOS/Ports
    ./src/uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS/Source
    ./src/uCOS-II/Source/: os_cfg.h ucos_ii.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group readme
    ./src/: Readme.txt
