# Keil uVision project vct6_os.uvproj, settings and files
target vct6_os (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: vct6_os +hex
  c flags: Optim=1
  c define: STM32F10X_HD USE_STDPERIPH_DRIVER
  c include: .\src\Libraries\CMSIS\CM3\CoreSupport;.\src\Libraries\STM32F10x_StdPeriph_Driver\inc;.\src\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\src;.\src\uCOS-II\Ports;.\src\uCOS-II\Source;.\src\menu;.\src\driver;.\src\task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup Files
    ./src/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ./src/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ./src/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Lib Files
    ./src/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_fsmc.c stm32f10x_pwr.c stm32f10x_dma.c
  group Include Files
    ./src/: app_cfg.h bsp.h stm32f10x_conf.h stm32f10x_it.h
  group Source Files
    ./src/: stm32f10x_it.c debug.c bsp.c main.c
  group task
    ./src/task/: task_app.h task_app.c task_lcd.c task_temp.c task_comm.c
  group Driver
    ./src/driver/: uart.c tft.c rtc.c ds18b20.c
  group protocal
    ./src/protocal/: protocal.c
  group menu
    ./src/menu/: F8x16.c FD36x48.c
  group uCOS/Ports
    ./src/uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS/Source
    ./src/uCOS-II/Source/: os_cfg.h ucos_ii.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
